# Keil uVision project uip_dm9051_demo.uvprojx, settings and files
target at_start_f437 (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.9
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f403a_freertos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,AT_START_F437_V1
  c include: ..\..\uIP;..\..\apps\dhcpc;..\..\apps\webserver;..\inc;..\src;..\..\dm9051_u2510_r_12_1;..\..\dm9051_u2510_if;..\..\..\libraries\drivers\inc;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\project\at32f435_437_board;..\..\..\middlewares\freertos_lwip_header;..\..\..\middlewares\freertos_lwip_header\port;..\..\..\middlewares\freertos_lwip_header\port\arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  link misc: --show_parent_lib --show_full_path
  group user
    ../src/: main.c at32f435_437_clock.c at32f435_437_int.c include_port.c uIP_cTask.c app_call.c RttPrintf.c tapdev.c
  group bsp
    ../../../project/at32f435_437_board/: at32f435_437_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group uip
    ../../uIP/: uip.c uip_arp.c timer.c psock.c
    ../src/: clock-arch.c
    ../../apps/dhcpc/: dhcpc.c
    ../../apps/webserver/: httpd.c httpd-fs.c httpd-cgi.c http-strings.c
  group dm9051
    ../../dm9051_u2510_r_12_1/core/: dm9051.c
    ../../dm9051_u2510_r_12_1/hal/SPI1/: at32f437_spi1.c
    ../../dm9051_u2510_if/common/nosys/: hex_dump.c
    ../../dm9051_u2510_r_12_1/hal/INT/: at32f437_int7.c
  group dm9051_platform
    ../../dm9051_u2510_if/common/port/: devif_uip.c plat_uip.c
    ../../dm9051_u2510_if/common/: platform_info_uip.c
  group httpd
    ../../../middlewares/freertos_tcpip_stack/src/apps/http/: _fs.c
    ../../lwip_web2403/: fs_jjdynamic.c
