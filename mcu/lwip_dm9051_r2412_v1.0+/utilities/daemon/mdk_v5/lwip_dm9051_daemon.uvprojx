# Keil uVision project lwip_dm9051_daemon.uvprojx, settings and files
target daemon (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.9
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ptp_daemon
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1
  c include: ..\..\..\libraries\drivers\inc;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\project\at32f435_437_board;..\..\..\middlewares\3rd_party\lwip_2.1.2\port;..\..\..\middlewares\3rd_party\lwip_2.1.2\port\arch;..\..\..\middlewares\3rd_party\lwip_2.1.2\src\include;..\..\..\middlewares\3rd_party\lwip_2.1.2\src\include\lwip;..\..\..\middlewares\3rd_party\ptpd-2.0.0\src;..\..\dm9051_u2510_if;..\..\dm9051_u2510_r_12_1;..\..\..\..\at32f437_ptpdaemon\source;..\edr_if
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main.c at32_emac.c netconf.c netconf_emac.c
    ../edr_if/: -core.c -debug_types_data.c -ethif.c
  group bsp
    ../../../project/at32f435_437_board/: at32f435_437_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_usart.c at32f435_437_emac.c at32f435_437_exint.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_scfg.c at32f435_437_tmr.c at32f435_437_spi.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group lwip
    ../../../middlewares/3rd_party/lwip_2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../middlewares/3rd_party/lwip_2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../middlewares/3rd_party/lwip_2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../middlewares/3rd_party/lwip_2.1.2/src/netif/: ethernet.c
    ../../../middlewares/3rd_party/lwip_2.1.2/port/: sys_arch.c ethernetif.c ethernetif_v51.c
  group dm9051_e
    ../../dm9051_u2510_r_12_1/core/: dm9051.c
    ../../dm9051_u2510_r_12_1/hal/SPI1/: at32f437_spi1.c
    ../../dm9051_u2510_r_12_1/hal/INT/: at32f437_int7.c
    ../../dm9051_u2510_if/common/nosys/: hex_dump.c
    ../../dm9051_u2510_if/common/port/: plat_lwip.c
  group dm9051_platform
    ../../dm9051_u2510_if/common/: platform_info_lwip.c
    ../../dm9051_u2510_if/common/port/: devif_lwip.c
  group web
    ../../lwip_web2403v2_freelw/: fs_jjdynamic.c httpd.c
